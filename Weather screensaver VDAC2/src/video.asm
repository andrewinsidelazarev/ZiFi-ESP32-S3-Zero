; Экран заставки на VDAC2: включить FT812 вместо изображения TS-Conf и
; вернуть экран Wild Commander.
;
; Что показывает монитор, решает регистр TS-Conf VCONFIG (#00AF): значение #04
; — изображение с FT812. Писать в порт напрямую бесполезно: WC хранит теневые
; значения видеорегистров, и его обработчик прерывания каждый кадр выводит их
; в порты (процедура VPRT). Поэтому режим задаётся функцией WC 66 (GVmod) —
; она кладёт значение в тень, и дальше WC сам держит FT812 на экране. Возврат
; к тексту — MNGV_PL с нулём: внутри WC это GEDPL, он восстанавливает режим,
; смещения и палитру WC.

VID_MODE_FT812  equ #04                 ; VCONFIG: изображение с FT812

; Подготовка экрана: запустить FT812 в 1024x768@59 и загрузить в него шрифты
; и иконки. Выход: CF=1 — экрана нет (платы VDAC2 нет или чип не справился);
; тогда главный цикл сразу выходит.
Video_Begin:
        ld a,#FF
        ld (DataCurPage),a              ; «ничего не подключено»
        xor a
        ld (ScreenDirty),a
        call FT_Boot
        ret c
        jp FT_LoadAssets

; Показать экран FT812 (кадр к этому времени уже собран).
; У функций WC параметр — в A' (альтернативном A), а номер функции — в A.
; EX AF,AF' меняет местами пары AF и AF': значение уходит в A', и A
; освобождается под номер функции.
Video_Show:
        ld a,VID_MODE_FT812
        ex af,af'                       ; A' = режим «FT812»
        ld a,FN_GVMOD
        jp WC_API

; Вернуть текстовый экран WC. GEDPL пишет палитру WC через окно FMADDR на
; #1000 и заодно портит #1000..#1447 страницы, подключённой к #0000, поэтому
; сначала подключается страница GEDPL_SAFE_PAGE, у которой этот участок пуст
; (tools/gen_assets.py): страницы данных остаются в памяти до следующего
; запуска заставки, и испорченные таблицы шрифтов испортили бы следующий кадр.
Video_End:
        ld a,GEDPL_SAFE_PAGE
        call Data_Page
        xor a
        ex af,af'                       ; A' = 0 — «вернуть текст WC»
        ld a,FN_MNGV_PL
        jp WC_API

; Подключить страницу данных плагина A к окну #0000 (функция WC 78, MNG0_PL).
; Повторный вызов с той же страницей ничего не делает. Сохраняет HL, DE, BC.
Data_Page:
        push hl
        ld hl,DataCurPage
        cp (hl)
        jr z,.done
        ld (hl),a
        push bc
        push de
        ex af,af'                       ; A' = номер страницы плагина
        ld a,FN_MNG0_PL
        call WC_API
        pop de
        pop bc
.done:
        pop hl
        ret

DataCurPage:    db #FF                  ; какая страница данных сейчас в #0000
