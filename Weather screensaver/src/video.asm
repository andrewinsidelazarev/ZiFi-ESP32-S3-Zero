; Видеорежим TS-Conf 360x288 на 256 цветов через функции Wild Commander.
;
; Прямых записей в VCONFIG/VPAGE (порты TS-Conf #00AF, #01AF) здесь нет и
; быть не может: WC хранит теневые значения видеорегистров, и его обработчик
; прерывания каждый кадр выводит их в порты (процедура VPRT в MD20.ASM).
; Записанное напрямую он через 1/50 секунды затёр бы. Поэтому режим задаётся
; функцией 66 (GVmod), а банк видеостраниц — 64 (MNGV_PL); возврат к тексту —
; тот же MNGV_PL с нулём, который внутри WC вызывает GEDPL и восстанавливает
; режим, смещения и палитру.
;
; Первый видеобуфер WC — 16 страниц по 16 КиБ (физические #20..#2F). В режиме
; 256c строка занимает 512 байт (видимы первые 360), на страницу приходится
; 32 строки; экран 288 строк — это 9 страниц. Рисуем, подключая нужную
; страницу к окну процессора #C000..#FFFF (функция 65, MNGCVPL).

VID_MODE_256C   equ %11000010           ; [7-6]=%11 360x288, [1-0]=%10 256c
VID_BANK        equ 1                   ; первый видеобуфер WC
VID_LINES_PAGE  equ 32                  ; строк на одной странице

; Подготовка: сброс кэша подключённых страниц и палитра в CRAM.
Video_Begin:
        ld a,#FF                        ; «ничего не подключено»
        ld (VidCurPage),a
        ld (DataCurPage),a
        jp Video_LoadPalette

; Показать кадр: режим и банк применятся на ближайшем прерывании WC.
; У функций WC параметр — в A' (альтернативном A), а номер функции — в A.
; EX AF,AF' меняет местами пары AF и AF': значение уходит в A', и A
; освобождается под номер функции.
Video_Show:
        ld a,VID_MODE_256C
        ex af,af'                       ; A' = видеорежим
        ld a,FN_GVMOD
        call WC_API
        ld a,VID_BANK
        ex af,af'                       ; A' = банк 1
        ld a,FN_MNGV_PL
        jp WC_API

; Вернуть текстовый экран WC (банк 0 = GEDPL: режим, смещения, палитра).
; GEDPL пишет палитру через окно FMADDR на #1000 и заодно портит #1000..#1447
; страницы, подключённой к #0000. Обычно там стоит страница шрифтов, и без
; подмены следующий запуск заставки рисовал бы битые буквы (так и было в
; Unreal: от названия места оставались
; первые буквы). Поэтому сначала подключается страница
; GEDPL_SAFE_PAGE, у которой этот участок оставлен пустым (tools/gen_assets.py).
Video_End:
        ld a,GEDPL_SAFE_PAGE
        call Data_Page
        xor a
        ex af,af'                       ; A' = 0 — «вернуть текст WC»
        ld a,FN_MNGV_PL
        jp WC_API

; Палитра: цвета 0..239 таблицы Palette в CRAM через окно FMADDR (#15AF).
; Формат слова: %0RRRRRGGGGGBBBBB (по 5 бит на красный, зелёный, синий).
;
; CRAM — память палитры TS-Conf; процессору она видна, только пока открыто
; окно FMADDR: значение #10 | (адрес окна >> 12) делает участок памяти
; «дверью» в CRAM. Запись в окно уходит и в CRAM, и в обычную память под
; окном (так устроен TS-Conf и так делает Unreal). Поэтому окно ставится на
; #C000 поверх видеостраницы 0: испорченная строка 0 экрана сразу после этого
; закрашивается фоном. Окно #0000 трогать нельзя — там рабочая страница
; Wild Commander. Цвета 240..255 не пишутся: ими WC рисует свой текстовый
; экран, который остаётся на мониторе, пока заставка готовит кадр.
; Прерывания на время записи запрещены (DI), чтобы обработчик WC не застал
; окно открытым.
PAL_LOADED      equ 240

Video_LoadPalette:
        ld hl,0
        call Video_Row                  ; видеостраница 0 — в окно #C000
        di
        ld bc,#15AF
        ld a,#1C                        ; FM_EN (#10) + окно с адреса #C000
        out (c),a
        ld hl,Palette
        ld de,#C000
        ld bc,PAL_LOADED*2              ; два байта на цвет
        ldir
        ld bc,#15AF
        xor a
        out (c),a                       ; закрыть окно
        ei
        ret

; Подключить к #C000 видеостраницу строки HL (0..287) и вернуть в HL адрес
; начала этой строки в окне. Страница = y/32, смещение = (y mod 32)*512.
; Портит AF и DE; BC сохраняется.
;
; Пример: y = 100 = %0110_0100. y mod 32 = %00100 = 4 -> смещение 4*512 =
; #0800, адрес #C800. y/32 = %011 = 3 -> страница 3.
Video_Row:
        ld a,l
        and #1F                         ; y mod 32
        add a,a                         ; *2 — старший байт смещения *512
        add a,#C0
        ld d,a                          ; D — старший байт адреса строки
        ld a,l
        and #E0                         ; биты 7..5 младшего байта y
        rlca
        rlca
        rlca                            ; биты 7..5 -> 2..0: y/32 внутри 0..7
        ld e,a
        ld a,h
        or a
        jr z,.page_ready                ; y < 256
        ld a,e
        or 8                            ; строки 256..287 — страница 8
        ld e,a
.page_ready:
        ld a,e
        ld hl,VidCurPage
        cp (hl)
        jr z,.same_page                 ; страница уже подключена — не звать WC
        ld (hl),a
        push bc
        push de
        ex af,af'                       ; A' = номер видеостраницы
        ld a,FN_MNGCVPL
        call WC_API
        pop de
        pop bc
.same_page:
        ld h,d
        ld l,0                          ; строки начинаются с границы 512 байт
        ret

; Подключить к #0000 страницу данных плагина A (1..3), если ещё не подключена.
; Сохраняет все регистры, кроме AF.
; Номер — относительный (0 — первая страница плагина); физический номер WC
; вычисляет сам. Запоминаем подключённую страницу, чтобы не вызывать WC
; лишний раз: вызов API заметно дороже сравнения.
Data_Page:
        push hl
        ld hl,DataCurPage
        cp (hl)
        jr z,.done
        ld (hl),a
        push bc
        push de
        ex af,af'                       ; A' = номер страницы плагина
        ld a,FN_MNG0_PL
        call WC_API
        pop de
        pop bc
.done:
        pop hl
        ret

VidCurPage:     db #FF                  ; какая видеостраница сейчас в #C000
DataCurPage:    db #FF                  ; какая страница данных сейчас в #0000
